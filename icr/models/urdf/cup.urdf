Commit message: qq

File: icr/models/urdf/cup.urdf (robot description, URDF)
Before this commit: robot cup_model, 1 links, 0 joints
Links:
- link cup: mass 0.1 -> 1
